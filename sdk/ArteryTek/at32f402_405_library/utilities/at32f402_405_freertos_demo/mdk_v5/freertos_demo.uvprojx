# Keil uVision project freertos_demo.uvprojx, settings and files
target 405_freertos_demo_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: IROM(0x08000000,0x3F0000) IRAM(0x20000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 405_freertos_demo_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f402_405_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c include_port.c
  group bsp
    ../../../project/at32f402_405_board/: at32f402_405_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_adc.c at32f402_405_can.c at32f402_405_crc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_dma.c at32f402_405_ertc.c at32f402_405_exint.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_spi.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_wdt.c at32f402_405_wwdt.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target 405_freertos_demo_ac6 (6160000::V6.16::ARMCLANG)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: as above
  output: 405_freertos_demo_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f402_405_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
target 402_freertos_demo_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F402RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 402_freertos_demo_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F402RCT7,USE_STDPERIPH_DRIVER,AT_START_F402_V1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
target 402_freertos_demo_ac6 (6160000::V6.16::ARMCLANG)
  device: AT32F402RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: as above
  output: 402_freertos_demo_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F402RCT7,USE_STDPERIPH_DRIVER,AT_START_F402_V1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
