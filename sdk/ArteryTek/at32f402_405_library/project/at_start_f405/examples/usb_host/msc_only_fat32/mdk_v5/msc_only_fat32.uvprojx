# Keil uVision project msc_only_fat32.uvprojx, settings and files
target msc_only_fat32_hs (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: msc_only_fat32_hs +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1,USB_OTG_HS
  c include: ..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\at32f402_405_board;..\inc;..\..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\..\middlewares\usbh_class\usbh_msc;..\..\..\..\..\..\middlewares\3rd_party\fatfs\source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c usbh_user.c usbh_msc_diskio.c
  group bsp
    ../../../../../at32f402_405_board/: at32f402_405_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_crm.c at32f402_405_exint.c at32f402_405_gpio.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_scfg.c at32f402_405_usart.c at32f402_405_usb.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group usbh_driver
    ../../../../../../middlewares/usb_drivers/src/: usb_core.c usbh_core.c usbh_ctrl.c usbh_int.c
  group usbh_class
    ../../../../../../middlewares/usbh_class/usbh_msc/: usbh_msc_class.c usbh_msc_bot_scsi.c
  group fatfs
    ../../../../../../middlewares/3rd_party/fatfs/source/: ff.c
  group readme
    ../: readme.txt
target msc_only_fat32_fs (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: as above
  output: msc_only_fat32_fs +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1,USB_OTG_FS
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x19800
