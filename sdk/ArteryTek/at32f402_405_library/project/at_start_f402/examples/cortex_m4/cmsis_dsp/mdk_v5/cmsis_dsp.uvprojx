# Keil uVision project cmsis_dsp.uvprojx, settings and files
target cmsis_dsp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F402RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cmsis_dsp +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F402RCT7,USE_STDPERIPH_DRIVER,AT_START_F402_V1,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c include: ..\inc;..\..\..\..\..\at32f402_405_board;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\dsp\include;..\..\..\..\..\..\libraries\cmsis\dsp\PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: main.c at32f402_405_int.c at32f402_405_clock.c
  group bsp
    ../../../../../at32f402_405_board/: at32f402_405_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group firmware
    ../../../../../../libraries/drivers/src/: at32f402_405_crm.c at32f402_405_gpio.c at32f402_405_misc.c at32f402_405_usart.c
  group cmsis_dsp
    ../../../../../../libraries/cmsis/dsp/source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/BayesFunctions/: BayesFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/CommonTables/: CommonTables.c
    ../../../../../../libraries/cmsis/dsp/source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/ControllerFunctions/: ControllerFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/DistanceFunctions/: DistanceFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/FastMathFunctions/: FastMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/FilteringFunctions/: FilteringFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/MatrixFunctions/: MatrixFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/SVMFunctions/: SVMFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/SupportFunctions/: SupportFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/TransformFunctions/: TransformFunctions.c
  group readme
    ../: readme.txt
