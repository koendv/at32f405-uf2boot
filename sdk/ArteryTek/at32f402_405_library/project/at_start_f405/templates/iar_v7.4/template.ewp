# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F405RCT7_v2 ArteryTek AT32F405RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F405RCT7; USE_STDPERIPH_DRIVER; AT_START_F405_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f402_405_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32f402_405_board/: at32f402_405_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f402_405.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
  group firmware
    ../../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_adc.c at32f402_405_can.c at32f402_405_crc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_dma.c at32f402_405_ertc.c at32f402_405_exint.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_spi.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_wdt.c at32f402_405_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c
