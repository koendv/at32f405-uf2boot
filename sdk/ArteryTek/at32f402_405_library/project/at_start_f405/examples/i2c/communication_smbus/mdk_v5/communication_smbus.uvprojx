# Keil uVision project communication_smbus.uvprojx, settings and files
target communication_smbus (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: communication_smbus +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f402_405_board;..\..\..\..\..\..\middlewares\i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c
  group bsp
    ../../../../../at32f402_405_board/: at32f402_405_board.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_crm.c at32f402_405_dma.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_usart.c at32f402_405_misc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group readme
    ../: readme.txt
