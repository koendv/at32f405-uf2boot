# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: AT32F405RCT7 ArteryTek
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f402_405_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c
  group bsp
    ../../../at32f402_405_board/: at32f402_405_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group firmware
    ../../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_adc.c at32f402_405_can.c at32f402_405_crc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_dma.c at32f402_405_ertc.c at32f402_405_exint.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_spi.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_wdt.c at32f402_405_wwdt.c
  group readme
    ../: readme.txt
